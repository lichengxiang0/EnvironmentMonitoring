# Keil uVision project RTK01_DMZ.uvprojx, settings and files
target RTK01_DMZ (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: fromelf.exe --bin -o./output/output.bin ./output/output.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\FATFS;..\FATFS\exfuns;..\FATFS\src;..\HARDWARE\Cam_FIFO;..\HARDWARE\EXIT;..\HARDWARE\FILE_INI;..\HARDWARE\GPS;..\HARDWARE\LED;..\HARDWARE\MY_FIFO;..\HARDWARE\OLED;..\HARDWARE\OLED\I2C_OLED_MOTO;..\HARDWARE\OLED\OLED_BMP;..\HARDWARE\OLED\OLED_GUI_TXT;..\HARDWARE\OLED\OLED_GUI_TXT\W25QXX;..\HARDWARE\PLAY_DATA;..\HARDWARE\RTC;..\HARDWARE\SDIO;..\HARDWARE\SRAM_DATA;..\HARDWARE\TIMER;..\HARDWARE\TXT;..\HARDWARE\USART;..\IAP;..\library_V3.5\CORE;..\library_V3.5\STM32F10x;..\library_V3.5\STM32F10x_FWLib\inc;..\library_V3.5\SYSTEM\delay;..\library_V3.5\SYSTEM\sys;..\library_V3.5\SYSTEM\usart;..\MALLOC;..\HARDWARE\USART1_DMA;..\IAP\STM32_CRC;..\IAP\STMFLASH;..\Copyright;..\HARDWARE\IIC;..\TIME
  memory RVCT4: ROM 0x8000000 size 0x38000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Project
    ./: main.c
  group HARDWARE
    ../HARDWARE/Cam_FIFO/: Cam_FIFO.c
    ../HARDWARE/EXIT/: Exit.c
    ../HARDWARE/FILE_INI/: file_ini.c
    ../HARDWARE/GPS/: Gps.c GPS_DATE.c GPS_STA.c
    ../HARDWARE/LED/: Led.c
    ../HARDWARE/MY_FIFO/: MY_FIFO.C
    ../HARDWARE/PLAY_DATA/: PLAY_DATA.C
    ../HARDWARE/RTC/: Rtc.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/SRAM_DATA/: SRAM_DATA.c
    ../HARDWARE/TXT/: Txt.c
    ../HARDWARE/USART1_DMA/: USART1_DMA.c
    ../HARDWARE/IIC/: soft_iic.c
  group CORE
    ../library_V3.5/CORE/: core_cm3.c startup_stm32f10x_hd.s
  group OLED
    ../HARDWARE/OLED/I2C_OLED_MOTO/: M_data.c OLED.c Spi1.c
    ../HARDWARE/OLED/OLED_BMP/: OLED_BMP.c OLED_BMP_Font.c
    ../HARDWARE/OLED/OLED_GUI_TXT/: fontupd.c OLED_GUI.c OLED_TXT.c
    ../HARDWARE/OLED/OLED_GUI_TXT/W25QXX/: SPI.c W25QXX.c
  group STM32F10X
    ../library_V3.5/STM32F10x/: stm32f10x_it.c system_stm32f10x.c
  group Library
    ../library_V3.5/STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../library_V3.5/SYSTEM/delay/: delay.c
    ../library_V3.5/SYSTEM/sys/: sys.c
    ../library_V3.5/SYSTEM/usart/: usart.c
  group IAP
    ../IAP/: IAP_DATA.C IAP_EXE.C IAP_PLAY.C
    ../IAP/STM32_CRC/: STM32_CRC.c
    ../IAP/STMFLASH/: stmflash.c
  group FATFS
    ../FATFS/exfuns/: exfuns.c
    ../FATFS/src/: diskio.c ff.c mycc936.c
  group MALLOC
    ../MALLOC/: Malloc.c
  group Copyright
    ../Copyright/: Copyright.c
  group 修正及方案
    ../: 方案及修正.txt
